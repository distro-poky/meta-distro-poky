SRC_URI = " \
    git://github.com/containers/libpod.git;branch=main \
"

# RCONFLICTS_${PN}_remove = " docker"
