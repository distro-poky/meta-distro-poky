SRC_URI = " \
    git://github.com/containers/skopeo;branch=main \
    file://storage.conf \
    file://registries.conf \
"
